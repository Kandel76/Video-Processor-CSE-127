VERSION 5.8 ;
BUSBITCHARS "[]" ;

MACRO PIXEL_ARRAY
  CLASS BLOCK ;
  FOREIGN PIXEL_ARRAY 0 0 ;
  ORIGIN 0 0 ;

  SIZE 2754.18 BY 2059.2 ;


  // POWER

  PIN VDD
    DIRECTION INOUT ;
    USE POWER ;
    PORT
      LAYER Metal1 ;
        RECT 0 0 2754.18 2059.2 ;
    END
  END VDD


  // ROW CONTROL (left→right wires)

  PIN RESET
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0 0 10 2059.2 ;
    END
  END RESET

  PIN ROW_SELECT
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0 0 10 2059.2 ;
    END
  END ROW_SELECT


  // COLUMN OUTPUTS (top/bottom access)

  PIN COLUMN_OUTPUT
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0 2049.2 2754.18 2059.2 ;
    END
    PORT
      LAYER Metal2 ;
        RECT 0 0 2754.18 10 ;
    END
  END COLUMN_OUTPUT

END PIXEL_ARRAY
